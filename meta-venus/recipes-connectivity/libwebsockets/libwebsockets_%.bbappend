FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-CMAKE_C_COMPILER_ID-is-not-set-for-some-reason.patch"
