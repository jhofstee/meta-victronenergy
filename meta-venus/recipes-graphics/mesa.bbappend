# The canvu500 needs etnaviv and sunxi needs lima.
PACKAGECONFIG:append = " etnaviv lima"
